inherit cmake

DESCRIPTION = "Gumstix + DSP SPI interface test."
LICENSE = "BSD"
PR = "r0"

S = "${WORKDIR}/git"

SRCREV = master
SRC_URI = "git://github.com/dimasad/gumstix-dsp-spitest.git;protocol=git"

